# Keil uVision project can_uart.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F042F6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: can_uart
  c flags: Optim=2 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F042,
  c include: .\Source;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\Libraries\STM32F0xx_StdPeriph_Driver\src;.\SSD1306
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group User
    ./Source/: main.c drv_system.c board.h drv_system.h config.h function.h config.c function.c
  group Driver
    ./Source/: drv_spi.c drv_spi.h
  group LCD
    ./SSD1306/: Fonts.h lcd_Display.h MacroAndConst.h SSD1306.h Fonts.c lcd_Display.c SSD1306.c
  group CAN-BUS
    ./Source/: drv_can.c can_queue.c can_queue.h drv_can.h
  group Std_Periph_Driver
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
software components: Device:Startup 1.5.0
